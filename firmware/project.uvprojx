# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: ARM_MATH_LOOPUNROLL, LFS_CONFIG=lfs_config.h, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F411xE, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\sim76xx;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;board\ports\dma_config;packages\fal-latest\inc;board\ports\fal;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\FlashDB-latest\inc;packages\jsmn-latest\inc;packages\jsmn-latest\test;.;rt-thread\include;board\ports\lcd;board\ports\lcd\1_3_IPS_LCD;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include;packages\littlefs-latest;LizCubic;LizCubic\app;LizCubic\app\weather;LizCubic\app\spectrum;LizCubic\app\hearbeat;LizCubic\app\anniversary;LizCubic\bsp;LizCubic\bsp\KVDB;LizCubic\bsp\LCD;LizCubic\bsp\ADC_FFT;LizCubic\bsp\IMU;LizCubic\bsp\WS2812B;LizCubic\bsp\BH1750;LizCubic\sys;LizCubic\common;LizCubic\network;LizCubic\config;packages\LVGL-v8.1.0\src;packages\LVGL-v8.1.0\src\core;packages\LVGL-v8.1.0\src\draw;packages\LVGL-v8.1.0\src\extra;packages\LVGL-v8.1.0\src\font;packages\LVGL-v8.1.0\src\gpu;packages\LVGL-v8.1.0\src\hal;packages\LVGL-v8.1.0\src\misc;packages\LVGL-v8.1.0\src\widgets;packages\LVGL-v8.1.0\src\extra\layouts;packages\LVGL-v8.1.0\src\extra\libs;packages\LVGL-v8.1.0\src\extra\others;packages\LVGL-v8.1.0\src\extra\themes;packages\LVGL-v8.1.0\src\extra\widgets;packages\LVGL-v8.1.0\src\extra\layouts\flex;packages\LVGL-v8.1.0\src\extra\layouts\grid;packages\LVGL-v8.1.0\src\extra\libs\bmp;packages\LVGL-v8.1.0\src\extra\libs\freetype;packages\LVGL-v8.1.0\src\extra\libs\fsdrv;packages\LVGL-v8.1.0\src\extra\libs\gif;packages\LVGL-v8.1.0\src\extra\libs\png;packages\LVGL-v8.1.0\src\extra\libs\qrcode;packages\LVGL-v8.1.0\src\extra\libs\rlottie;packages\LVGL-v8.1.0\src\extra\libs\sjpg;packages\LVGL-v8.1.0\src\extra\others\snapshot;packages\LVGL-v8.1.0\src\extra\themes\basic;packages\LVGL-v8.1.0\src\extra\themes\default;packages\LVGL-v8.1.0\src\extra\themes\mono;packages\LVGL-v8.1.0\src\extra\widgets\animimg;packages\LVGL-v8.1.0\src\extra\widgets\calendar;packages\LVGL-v8.1.0\src\extra\widgets\chart;packages\LVGL-v8.1.0\src\extra\widgets\colorwheel;packages\LVGL-v8.1.0\src\extra\widgets\imgbtn;packages\LVGL-v8.1.0\src\extra\widgets\keyboard;packages\LVGL-v8.1.0\src\extra\widgets\led;packages\LVGL-v8.1.0\src\extra\widgets\list;packages\LVGL-v8.1.0\src\extra\widgets\meter;packages\LVGL-v8.1.0\src\extra\widgets\msgbox;packages\LVGL-v8.1.0\src\extra\widgets\span;packages\LVGL-v8.1.0\src\extra\widgets\spinbox;packages\LVGL-v8.1.0\src\extra\widgets\spinner;packages\LVGL-v8.1.0\src\extra\widgets\tabview;packages\LVGL-v8.1.0\src\extra\widgets\tileview;packages\LVGL-v8.1.0\src\extra\widgets\win;packages\LVGL-v8.1.0\src\gpu\sdl;applications\lvgl;packages\LVGL-v8.1.0\rt-thread;packages\MotionDriver2RTT-latest\core;packages\MotionDriver2RTT-latest\core\driver\eMPL;packages\MotionDriver2RTT-latest\core\driver\include;packages\MotionDriver2RTT-latest\core\driver\stm32L;packages\MotionDriver2RTT-latest\core\eMPL-hal;packages\MotionDriver2RTT-latest\core\mllite;packages\MotionDriver2RTT-latest\core\mpl;packages\MotionDriver2RTT-latest\port;packages\pahomqtt-latest\MQTTPacket\src;packages\pahomqtt-latest\MQTTClient-RT;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ymodem;packages\webclient-latest\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_client.c at_utils.c at_cli.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/samples/: at_sample_sim76xx.c
    packages/at_device-latest/class/sim76xx/: at_socket_sim76xx.c at_device_sim76xx.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: ringbuffer.c pipe.c waitqueue.c ringblk_buf.c completion.c workqueue.c dataqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_rtc.c drv_soft_i2c.c drv_wdt.c drv_usart.c drv_common.c
    board/ports/flash/: drv_spi_flash.c
  group fal
    packages/fal-latest/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group FlashDB
    packages/FlashDB-latest/src/: fdb_utils.c fdb.c fdb_tsdb.c fdb_file.c fdb_cmd.c fdb_kvdb.c
  group jsmn
    packages/jsmn-latest/src/: jsmn.c
  group Kernel
    rt-thread/src/: object.c scheduler.c timer.c mempool.c mem.c thread.c ipc.c kservice.c device.c clock.c idle.c components.c irq.c
  group LCD
    board/ports/lcd/1_3_IPS_LCD/: drv_lcd.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: mem_std.c syscalls.c libc.c stdio.c
    rt-thread/components/libc/compilers/common/: delay.c unistd.c time.c stdlib.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc.c stm32f4xx_hal.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group littlefs
    packages/littlefs-latest/: lfs_crc.c lfs.c lfs_util.c dfs_lfs.c
  group LizCubic
    LizCubic/app/fonts/: lv_font_ibmplex_115.c lv_font_ibmplex_64.c jb_monob_22.c msyhbd_24.c msyhbd_22.c jb_monob_yahei_22.c msyhbd_18.c
    LizCubic/bsp/IMU/: imu_action.c
    LizCubic/network/: network.c liz_mqtt.c
    LizCubic/: liz_app.c
    LizCubic/app/anniversary/: anniversary_gui.c anniversary.c
    LizCubic/sys/: sys_ntp.c app_controller.c lcd_autoLight.c system_start_gui.c
    LizCubic/bsp/ADC_FFT/: adc_fft.c
    LizCubic/bsp/KVDB/: kvdb.c
    LizCubic/bsp/LCD/: spi_lcd.c
    LizCubic/app/spectrum/: spectrum.c spectrum_gui.c
    LizCubic/common/: color_gradient.c
    LizCubic/app/hearbeat/: heartbeat.c heartbeat_gui.c
    LizCubic/bsp/WS2812B/: ws2812b.c
    LizCubic/app/imgs/: weather_ico.c
    LizCubic/bsp/: liz_bsp.c
    LizCubic/app/weather/: weather_gui.c weather.c
    LizCubic/bsp/BH1750/: bh1750.c
  group LVGL
    packages/LVGL-v8.1.0/src/widgets/: lv_btnmatrix.c lv_slider.c lv_arc.c lv_textarea.c lv_line.c lv_bar.c lv_switch.c lv_roller.c lv_canvas.c lv_btn.c lv_label.c lv_objx_templ.c lv_dropdown.c lv_checkbox.c lv_img.c lv_table.c
    packages/LVGL-v8.1.0/src/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.1.0/src/misc/: lv_log.c lv_anim_timeline.c lv_color.c lv_anim.c lv_txt_ap.c lv_mem.c lv_tlsf.c lv_math.c lv_printf.c lv_templ.c lv_ll.c lv_gc.c lv_style_gen.c lv_txt.c lv_area.c lv_bidi.c lv_async.c lv_timer.c lv_style.c lv_utils.c lv_fs.c
    packages/LVGL-v8.1.0/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-v8.1.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.1.0/src/core/: lv_obj_scroll.c lv_obj_pos.c lv_obj_class.c lv_indev.c lv_indev_scroll.c lv_obj_style_gen.c lv_disp.c lv_event.c lv_theme.c lv_obj_tree.c lv_obj_style.c lv_refr.c lv_obj_draw.c lv_group.c lv_obj.c
    packages/LVGL-v8.1.0/src/gpu/sdl/: lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_utils.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_lru.c lv_gpu_sdl_mask.c
    packages/LVGL-v8.1.0/src/font/: lv_font_montserrat_42.c lv_font_montserrat_34.c lv_font_montserrat_32.c lv_font_montserrat_22.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_26.c lv_font_montserrat_48.c lv_font_montserrat_30.c lv_font_unscii_8.c lv_font_montserrat_18.c lv_font_montserrat_8.c lv_font_loader.c lv_font_montserrat_24.c lv_font_montserrat_12.c lv_font_montserrat_10.c lv_font_montserrat_16.c lv_font_montserrat_20.c lv_font_simsun_16_cjk.c lv_font_montserrat_38.c lv_font_montserrat_46.c lv_font_montserrat_14.c lv_font_unscii_16.c lv_font_montserrat_28.c lv_font_montserrat_12_subpx.c lv_font_montserrat_28_compressed.c lv_font_montserrat_44.c lv_font_montserrat_40.c lv_font_fmt_txt.c lv_font.c lv_font_montserrat_36.c
    packages/LVGL-v8.1.0/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.1.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.1.0/src/draw/: lv_draw_blend.c lv_draw_img.c lv_draw_arc.c lv_img_buf.c lv_img_decoder.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_img_cache.c lv_draw_mask.c lv_draw_triangle.c
    packages/LVGL-v8.1.0/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.1.0/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.1.0/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_posix.c lv_fs_win32.c lv_fs_fatfs.c
    packages/LVGL-v8.1.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.1.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.1.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.1.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.1.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.1.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.1.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.1.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.1.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.1.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.1.0/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.1.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.1.0/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.1.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.1.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.1.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.1.0/src/extra/: lv_extra.c
    packages/LVGL-v8.1.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.1.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.1.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.1.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.1.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.1.0/src/extra/layouts/flex/: lv_flex.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    packages/LVGL-v8.1.0/rt-thread/: lv_rt_thread_port.c
  group MotionDriver
    packages/MotionDriver2RTT-latest/core/eMPL-hal/: eMPL_outputs.c
    packages/MotionDriver2RTT-latest/core/mllite/: storage_manager.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c start_manager.c mpl.c results_holder.c data_builder.c
    packages/MotionDriver2RTT-latest/core/driver/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    packages/MotionDriver2RTT-latest/core/driver/stm32L/: log_stm32.c
    packages/MotionDriver2RTT-latest/port/: MD_Ported_to_RTT.c
    packages/MotionDriver2RTT-latest/mpl libraries/arm/Keil/libmpllib_Keil_M4/: libmpllib.lib
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTFormat.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c MQTTConnectServer.c MQTTConnectClient.c MQTTSubscribeClient.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_sockets.c net_netdb.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor_cmd.c sensor.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
  group WebClient
    packages/webclient-latest/src/: webclient.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
